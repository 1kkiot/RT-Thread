# Keil uVision project RT-Thread-Demo-project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RT-Thread-Demo-project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Core;..\HAL\STM32F4xx_HAL_Driver\Inc;..\HAL\STM32F4xx_HAL_Driver\Inc\Legacy;..\User;..\HAL;..\Sys;..\Task;..\RT-Thread\3.1.2\bsp;..\RT-Thread\3.1.2\include;..\RT-Thread\3.1.2\include\libc;..\RT-Thread\3.1.2\src;..\RT-Thread\3.1.2\components\finsh;..\RT-Thread\3.1.2\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ../HAL/: startup_stm32f407xx.s
  group HAL
    ../HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c
  group Sys
    ../Sys/: SysClock.c SysClock.h SysGpio.c SysGpio.h SysUart.c SysUart.h
  group RT_Thread_bsp
    ../RT-Thread/3.1.2/bsp/: board.c board.h rtconfig.h
  group RT_Thread_cpu
    ../RT-Thread/3.1.2/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group RT_Thread_src
    ../RT-Thread/3.1.2/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group RT_Thread_finsh
    ../RT-Thread/3.1.2/components/finsh/: cmd.c finsh.h finsh_api.h msh.c msh.h msh_cmd.c msh_file.c shell.c shell.h symbol.c
  group RT_Thread_dev
    ../RT-Thread/3.1.2/components/drivers/serial/: serial.c
    ../RT-Thread/3.1.2/components/drivers/src/: completion.c
  group Task
    ../Task/: Task.c Task.h TaskInit.c TaskInit.h
  group User
    ../User/: main.c stm32f4xx.h stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h stm32f407xx.h system_stm32f4xx.c system_stm32f4xx.h
  group ReadME
    ../ReadME/: ReadMe.txt
